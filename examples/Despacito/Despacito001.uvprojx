# Keil uVision project Despacito001.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Despacito001
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Start;.\User;.\Library;.\FreeRTOS\freertos include;.\FreeRTOS\freertos portable\GCC\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS port
    ./FreeRTOS/freertos portable/MemMang/: heap_4.c
    ./FreeRTOS/freertos portable/GCC/ARM_CM3/: port.c portmacro.h
  group FreeRTOS src
    ./FreeRTOS/freertos src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
